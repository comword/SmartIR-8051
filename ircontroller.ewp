# IAR project ircontroller.ewp, settings and files
configuration Coordinator (8051, debug)
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.CCDefines: SECURE=1; TC_LINKKEY_JOIN; NV_INIT; xNV_RESTORE; xHOLD_AUTO_START; ZTOOL_P1; MT_TASK; MT_APP_FUNC; MT_SYS_FUNC; MT_ZDO_FUNC; MULTICAST_ENABLED=FALSE; ZCL_READ; ZCL_WRITE; ZCL_REPORT; ZCL_EZMODE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_ON_OFF; ZCL_DIAGNOSTIC; FEATURE_SYSTEM_STATS
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ZMain; osal\include; hal\include; hal\target\CC2530EB; mac\high_level; mac\include; mac\low_level; mac\low_level\single_chip; services\saddr; services\sdata; mt; stack\nwk; stack\af; zmac; zmac\f8w; stack\sec; stack\zdo; stack\zcl; stack\sys; stack\sapi; app
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: Tools\f8w2530.xcl
configuration End device (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: SECURE=1; TC_LINKKEY_JOIN; NV_INIT; xNV_RESTORE; xPOWER_SAVING; NWK_AUTO_POLL; HOLD_AUTO_START; ZTOOL_P1; MT_TASK; MT_APP_FUNC; MT_SYS_FUNC; MT_ZDO_FUNC; MULTICAST_ENABLED=FALSE; ZCL_READ; ZCL_WRITE; ZCL_REPORT; ZCL_EZMODE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_ON_OFF; ZCL_SCENES; ZCL_GROUPS; xZCL_LEVEL_CTRL; ZCL_DIAGNOSTIC; FEATURE_SYSTEM_STATS
  group APP
    app/: osal_app.c smartir_app.c smartir_app.h
  group HAL
    hal/target/CC2530EB/: hal_adc.c hal_aes.h hal_board_cfg.h hal_ccm.h hal_dma.c hal_dma.h hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_mac_cfg.h hal_mcu.h hal_oad.c hal_oad.h hal_sleep.c hal_startup.c hal_timer.c hal_types.h hal_uart.c
    hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
    hal/common/: hal_assert.c hal_drivers.c
  group MAC
    mac/include/: mac_api.h
    mac/low_level/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
    mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.c mac_pib.h mac_spec.h
    mac/low_level/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h mac_rffrontend.c
  group MT
    mt/: DebugTrace.c DebugTrace.h MT.c MT.h MT_AF.c MT_AF.h MT_APP.c MT_APP.h MT_DEBUG.c MT_DEBUG.h MT_NWK.c MT_NWK.h MT_RPC.h MT_SAPI.c MT_SAPI.h MT_SYS.c MT_SYS.h MT_TASK.c MT_TASK.h MT_UART.c MT_UART.h MT_UTIL.c MT_UTIL.h MT_VERSION.c MT_VERSION.h MT_ZDO.c MT_ZDO.h
  group OSAL
    osal/include/: comdef.h OSAL.h OSAL_Clock.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h osal_task.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
    osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    osal/mcu/: OSAL_Math.s51 OSAL_Nv.c
  group Service
    services/saddr/: saddr.c saddr.h
    services/sdata/: sdata.h
  group Stack
    stack/nwk/: AddrMgr.h APS.h aps_frag.h aps_groups.h aps_util.h APSMEDE.h AssocList.h BindingTable.c BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.c nwk_globals.h nwk_util.h reflecttrack.h rtg.h stub_aps.c stub_aps.h
    stack/af/: AF.c AF.h
    stack/sec/: ssp.h ssp_hash.h
    stack/zcl/: zcl.c zcl.h zcl_diagnostic.c zcl_diagnostic.h zcl_ezmode.c zcl_ezmode.h zcl_general.c zcl_general.h zcl_ha.c zcl_ha.h
    stack/zdo/: ZDApp.c ZDApp.h ZDConfig.c ZDConfig.h ZDNwkMgr.c ZDNwkMgr.h ZDObject.c ZDObject.h ZDProfile.c ZDProfile.h ZDSecMgr.c ZDSecMgr.h
    stack/sys/: ZDiags.c ZDiags.h ZGlobals.c ZGlobals.h
  group ZMac
    zmac/f8w/: zmac.c zmac_cb.c zmac_internal.h
    zmac/: ZMAC.h
  group ZMain
    ZMain/: chipcon_cstartup.s51 OnBoard.c OnBoard.h ZMain.c
